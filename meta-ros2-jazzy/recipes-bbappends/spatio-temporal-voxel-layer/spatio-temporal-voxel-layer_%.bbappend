DEPENDS:remove = "openexr"
RDEPENDS:${PN}:remove = "openexr"

ROS_BUILDTOOL_DEPENDS:append = " rosidl-core-generators-native"
