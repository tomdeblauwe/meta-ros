ROS_BUILD_DEPENDS += " \
    rosidl-default-generators-native \
"

ROS_EXEC_DEPENDS += " \
    rosidl-default-runtime \
"
